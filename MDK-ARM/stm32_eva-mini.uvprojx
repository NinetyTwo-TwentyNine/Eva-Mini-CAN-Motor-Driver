# Keil uVision project stm32_eva-mini.uvprojx, settings and files
target stm32_eva-mini (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32_eva-mini +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F103xB,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Inc/: main.h
    ../Core/Src/: main.c stm32f1xx_it.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_can.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_dma.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_ll_spi.c stm32f1xx_ll_pwr.c stm32f1xx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/User/Libraries
    ../Core/Inc/: GFX_General.h GFX_SSD1306.h i2c_control.h mcp23008.h can_parser.h frequency_calc_basic.h params_calculation.h ui_screen_system.h ui_utilities.h ui_screen_start_menu.h ui_screen_main_menu.h ui_screen_seeder_options_menu.h ui_screen_errors_menu.h ui_screen_other_options_menu.h ui_screen_calibration_menu.h ui_screen_calibration_check_menu.h
    ../Core/Src/: GFX_General.c GFX_SSD1306.c i2c_control.c mcp23008.c can_parser.c frequency_calc_basic.c params_calculation.c ui_screen_system.c ui_utilities.c ui_screen_start_menu.c ui_screen_main_menu.c ui_screen_seeder_options_menu.c ui_screen_errors_menu.c ui_screen_other_options_menu.c ui_screen_calibration_menu.c ui_screen_calibration_check_menu.c
software components: CMSIS:CORE 6.1.0
